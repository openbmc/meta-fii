python() {
    d.setVar('VERSION_ID', "v0.6-00-kudo")
}
