FILESEXTRAPATHS_prepend_kudo := "${THISDIR}/${PN}:"

SRC_URI_append_kudo += " file://0001-Modify-power-control-for-Conan-project.patch"

