FILESEXTRAPATHS_append_kudo := "${THISDIR}/${PN}:"
