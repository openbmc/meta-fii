NUVOTON_FLASH_PCIMBOX = "0xF0848000"

EXTRA_OECONF_append_kudo = " --enable-nuvoton-p2a-mbox"

IPMI_FLASH_BMC_ADDRESS_kudo = "${NUVOTON_FLASH_PCIMBOX}"
