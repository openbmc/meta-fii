OBMC_IMAGE_EXTRA_INSTALL_append_kudo = " ipmitool ethtool"
IMAGE_INSTALL += "phosphor-ipmi-ssif"
