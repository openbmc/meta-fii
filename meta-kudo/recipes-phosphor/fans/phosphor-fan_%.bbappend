FILESEXTRAPATHS_prepend_kudo := "${THISDIR}/${PN}:"

#SRC_URI += "file://0001-mtjade-phosphor-fan-presence-Fix-condition-to-check-.patch \           "
